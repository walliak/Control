# Keil uVision project StepMotorControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: StepMotorControl
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Peripheral_H;.\Common
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Common
    ./Common/: Character.c CompositeChars.c
  group Peripheral
    ./Peripheral_C/: Init.c key.c lcd.c Timer3.c
